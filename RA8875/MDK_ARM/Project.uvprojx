# Keil uVision project Project.uvprojx, settings and files
target HT32 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: HT32F12366 Holtek
  pack: Holtek.HT32_DFP.1.0.12
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x3FC00) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HT32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F12366_DVB
  c include: ..\;..\..\library\HT32F12365_66_Driver\inc;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F12365_66\Include;..\..\library\HT32_USBD_Library\inc;..\..\utilities;..\FatFS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3fc00
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f12365_66_it.c sd_disk.c RA8875.c Converter.c Keypad.c RA8875_Touch.c TimerManager.c
    ../FatFS/: tff.c
  group Config
    ../: ht32f12365_66_conf.h ht32f12365_66_usbdconf.h
    ../MDK_ARM/: ht32_op.s
    ./: HT32F12365_66_DebugSupport.ini
  group CMSIS
    ../: system_ht32f12365_66.c
  group MDK-ARM
    ./: startup_ht32f12365_66.s
  group USBD_Library
    ../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../library/HT32F12365_66_Driver/src/: ht32_cm3_misc.c ht32f12365_66_adc.c ht32f12365_66_aes.c ht32f12365_66_bftm.c ht32f12365_66_ckcu.c ht32f12365_66_cmp.c ht32f12365_66_crc.c ht32f12365_66_ebi.c ht32f12365_66_exti.c ht32f12365_66_flash.c ht32f12365_66_gpio.c ht32f12365_66_gptm.c ht32f12365_66_i2c.c ht32f12365_66_i2s.c ht32f12365_66_mctm.c ht32f12365_66_pdma.c ht32f12365_66_pwrcu.c ht32f12365_66_rstcu.c ht32f12365_66_rtc.c ht32f12365_66_sci.c ht32f12365_66_sdio.c ht32f12365_66_spi.c ht32f12365_66_usart.c ht32f12365_66_usbd.c ht32f12365_66_wdt.c ht32f22366_csif.c
  group Retarget
    ../../library/HT32F12365_66_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/: ht32_board.c
    ../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c ebi_sram.c MX25L512.c spi_flash_common.c
software components: CMSIS:CORE 4.3.0
